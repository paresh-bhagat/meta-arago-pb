MESA_DEMOS_ARAGO = ""
MESA_DEMOS_ARAGO:arago = "mesa-demos-arago.inc"

require ${MESA_DEMOS_ARAGO}
